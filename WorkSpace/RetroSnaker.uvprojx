# Keil uVision project RetroSnaker.uvprojx, settings and files
target RetroSnaker (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RetroSnaker
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Code\CORE;..\Code\FWLIB\inc;..\Code\HARDWARE\DFC;..\Code\HARDWARE\ESP8266_AT;..\Code\HARDWARE\RNG;..\Code\HARDWARE\TFTLCD_FSMC;..\Code\HARDWARE\USART;..\Code\MAIN;..\Code\SYSTEM;..\Code\HARDWARE\SNAKE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../Code/CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../Code/FWLIB/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_usart.c
  group SYSTEM
    ../Code/SYSTEM/: delay.c stm32f4xx_it.c sys.c system_stm32f4xx.c
  group HARDWARE
    ../Code/HARDWARE/DFC/: DFC.c
    ../Code/HARDWARE/ESP8266_AT/: ESP8266_AT.c
    ../Code/HARDWARE/TFTLCD_FSMC/: Font_ASCII.c FSMC.c FSMC_GPIO.c TFTLCD.c TFTLCD_GPIO.c
    ../Code/HARDWARE/USART/: USART.c USART_GPIO.c USART_NVIC.c
    ../Code/HARDWARE/SNAKE/: Snake.c Snake_Shape.c
    ../Code/HARDWARE/RNG/: RNG.c
  group MAIN
    ../Code/MAIN/: main.c
